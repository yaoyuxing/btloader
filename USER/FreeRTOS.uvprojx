# Keil uVision project FreeRTOS.uvprojx, settings and files
target BootLoader (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F769NIHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.8.0
  cpu: IROM(0x08000000,0x200000) IROM2(0x00200000,0x200000) IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: LED +hex
  AfterMake: D:\Program Files (X86)\ARM\ARMCC\bin\fromelf.exe  --bin -o  ../BIN/stm32f7_FreeRTOS.bin  ../OBJ/LED.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F769xx,USE_HAL_DRIVER,ARM_MATH_CM7,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c misc: --c99
  c include: ..\CORE;..\OBJ;..\USER;..\HALLIB\STM32F7xx_HAL_Driver\Inc;..\SYSTEM\delay;..\SYSTEM\sys;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM7\r0p1;..\NorFlash;..\FATFS\source;..\InterFlash;..\F769_USART;..\Ymodem;..\Update;..\BleTooth;..\CRC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
  group USER
    ./: main.c stm32f7xx_it.c system_stm32f7xx.c
  group CORE
    ../CORE/: cmsis_armcc.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
    ./: startup_stm32f769xx.s
  group HALLIB
    ../HALLIB/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_sdram.c stm32f7xx_ll_fmc.c stm32f7xx_hal_spi.c stm32f7xx_hal_nor.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_flash.c stm32f7xx_ll_dma2d.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_dma.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group USART
    ../F769_USART/: uart.c uart.h
  group NorFlash
    ../NorFlash/: my_norflash.c
  group FatFs
    ../FATFS/source/: ff.c diskio.c ffsystem.c ffunicode.c
  group InterFlash
    ../InterFlash/: interflash.c interflash.h
  group Ymodem
    ../Ymodem/: ymodem.c ymodem.h
  group LocalUartUpdate
    ../BleTooth/: ble_tooth.h ble_tooth.c
    ../Update/: ble_update.h ble_update.c
  group bootloader
    ../Update/: bootloader.h bootloader.c
  group system_info
    ../InterFlash/: system_info.c system_info.h
  group CRC16
    ../CRC/: crc16.c crc16.h
